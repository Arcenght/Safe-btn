## build/safebtn/Kconfig/boards/Kconfig.defconfig.tmp
```kconfig
# Load Zephyr board defconfig descriptions.
osource "C:/ncs/v3.4.0/zephyr/boards/others/promicro_nrf52840/Kconfig.defconfig"
```
